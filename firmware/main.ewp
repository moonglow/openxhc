# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: src; STM32_USB-FS-Device_Driver\inc; STM32F10x_StdPeriph_Driver\inc; CMIS\Device\STM32F10x\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: main.bin
  group CMIS
    CMIS/Device/STM32F10x/Source/Templates/iar/: startup_stm32f10x_md.s
  group STM3210x_LIB
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
  group USB_LIB
    STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USER
    src/: hw_config.c main.c stm32_it.c system_stm32f10x.c
  group USER/DRIVERS
    src/: font5x8.c nokia_lcd.c spi_master.c
  group USER/USB_STUFF
    src/: usb_istr.c usb_prop.c usb_pwr.c
