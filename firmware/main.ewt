<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMIS</name>
    <file>
      <name>$PROJ_DIR$\CMIS\Device\STM32F10x\Source\Templates\iar\startup_stm32f10x_md.s</name>
    </file>
  </group>
  <group>
    <name>STM3210x_LIB</name>
    <file>
      <name>$PROJ_DIR$\STM32F10x_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F10x_StdPeriph_Driver\src\stm32f10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F10x_StdPeriph_Driver\src\stm32f10x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
    </file>
  </group>
  <group>
    <name>USB_LIB</name>
    <file>
      <name>$PROJ_DIR$\STM32_USB-FS-Device_Driver\src\usb_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32_USB-FS-Device_Driver\src\usb_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32_USB-FS-Device_Driver\src\usb_int.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32_USB-FS-Device_Driver\src\usb_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32_USB-FS-Device_Driver\src\usb_regs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32_USB-FS-Device_Driver\src\usb_sil.c</name>
    </file>
  </group>
  <group>
    <name>USER</name>
    <group>
      <name>DRIVERS</name>
      <group>
        <name>LCD</name>
        <file>
          <name>$PROJ_DIR$\src\erc12864_4.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\hd44780.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\lcd_st7735.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\nokia_lcd.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\src\io_input.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\kbd_driver.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\spi_master.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\string_utils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\timer_drv.c</name>
      </file>
    </group>
    <group>
      <name>USB_STUFF</name>
      <file>
        <name>$PROJ_DIR$\src\usb_istr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\usb_prop.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\usb_pwr.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\src\hw_config.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\stm32_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\system_stm32f10x.c</name>
    </file>
  </group>
</project>


